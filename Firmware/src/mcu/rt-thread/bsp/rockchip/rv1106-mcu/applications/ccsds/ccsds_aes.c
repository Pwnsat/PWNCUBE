/*
 * ccsds_aes — AES-128 + CTR (byte-exact port of FlatSat/ElectronicCats, see .h).
 */

#include "ccsds_aes.h"
#include <string.h>

/* INTENTIONAL WEAKNESS (CTF): single fixed key, ASCII, in .rodata. */
const uint8_t CCSDS_TC_AES_KEY[CCSDS_AES_KEYLEN] = "PWNSAT_K3Y_2026!";

static const uint8_t sbox[256] = {
    0x63,0x7c,0x77,0x7b,0xf2,0x6b,0x6f,0xc5,0x30,0x01,0x67,0x2b,0xfe,0xd7,0xab,0x76,
    0xca,0x82,0xc9,0x7d,0xfa,0x59,0x47,0xf0,0xad,0xd4,0xa2,0xaf,0x9c,0xa4,0x72,0xc0,
    0xb7,0xfd,0x93,0x26,0x36,0x3f,0xf7,0xcc,0x34,0xa5,0xe5,0xf1,0x71,0xd8,0x31,0x15,
    0x04,0xc7,0x23,0xc3,0x18,0x96,0x05,0x9a,0x07,0x12,0x80,0xe2,0xeb,0x27,0xb2,0x75,
    0x09,0x83,0x2c,0x1a,0x1b,0x6e,0x5a,0xa0,0x52,0x3b,0xd6,0xb3,0x29,0xe3,0x2f,0x84,
    0x53,0xd1,0x00,0xed,0x20,0xfc,0xb1,0x5b,0x6a,0xcb,0xbe,0x39,0x4a,0x4c,0x58,0xcf,
    0xd0,0xef,0xaa,0xfb,0x43,0x4d,0x33,0x85,0x45,0xf9,0x02,0x7f,0x50,0x3c,0x9f,0xa8,
    0x51,0xa3,0x40,0x8f,0x92,0x9d,0x38,0xf5,0xbc,0xb6,0xda,0x21,0x10,0xff,0xf3,0xd2,
    0xcd,0x0c,0x13,0xec,0x5f,0x97,0x44,0x17,0xc4,0xa7,0x7e,0x3d,0x64,0x5d,0x19,0x73,
    0x60,0x81,0x4f,0xdc,0x22,0x2a,0x90,0x88,0x46,0xee,0xb8,0x14,0xde,0x5e,0x0b,0xdb,
    0xe0,0x32,0x3a,0x0a,0x49,0x06,0x24,0x5c,0xc2,0xd3,0xac,0x62,0x91,0x95,0xe4,0x79,
    0xe7,0xc8,0x37,0x6d,0x8d,0xd5,0x4e,0xa9,0x6c,0x56,0xf4,0xea,0x65,0x7a,0xae,0x08,
    0xba,0x78,0x25,0x2e,0x1c,0xa6,0xb4,0xc6,0xe8,0xdd,0x74,0x1f,0x4b,0xbd,0x8b,0x8a,
    0x70,0x3e,0xb5,0x66,0x48,0x03,0xf6,0x0e,0x61,0x35,0x57,0xb9,0x86,0xc1,0x1d,0x9e,
    0xe1,0xf8,0x98,0x11,0x69,0xd9,0x8e,0x94,0x9b,0x1e,0x87,0xe9,0xce,0x55,0x28,0xdf,
    0x8c,0xa1,0x89,0x0d,0xbf,0xe6,0x42,0x68,0x41,0x99,0x2d,0x0f,0xb0,0x54,0xbb,0x16
};

static const uint8_t rcon[11] = {
    0x8d,0x01,0x02,0x04,0x08,0x10,0x20,0x40,0x80,0x1b,0x36
};

void ccsds_aes128_key_expansion(const uint8_t key[16], uint8_t round_keys[176])
{
    int i, j;
    uint8_t temp[4];

    for (i = 0; i < 16; i++)
        round_keys[i] = key[i];

    for (i = 16; i < 176; i += 4) {
        memcpy(temp, &round_keys[i - 4], 4);
        if (i % 16 == 0) {
            uint8_t t = temp[0];
            temp[0] = temp[1];
            temp[1] = temp[2];
            temp[2] = temp[3];
            temp[3] = t;
            temp[0] = sbox[temp[0]];
            temp[1] = sbox[temp[1]];
            temp[2] = sbox[temp[2]];
            temp[3] = sbox[temp[3]];
            temp[0] ^= rcon[i / 16];
        }
        for (j = 0; j < 4; j++)
            round_keys[i + j] = round_keys[i - 16 + j] ^ temp[j];
    }
}

static void add_round_key(uint8_t *state, const uint8_t *round_key)
{
    for (int i = 0; i < 16; i++)
        state[i] ^= round_key[i];
}

static void sub_bytes(uint8_t *state)
{
    for (int i = 0; i < 16; i++)
        state[i] = sbox[state[i]];
}

static void shift_rows(uint8_t *state)
{
    uint8_t t;
    t = state[1];  state[1]=state[5];  state[5]=state[9];  state[9]=state[13];  state[13]=t;
    t = state[2];  state[2]=state[10]; state[10]=t;
    t = state[6];  state[6]=state[14]; state[14]=t;
    t = state[15]; state[15]=state[11];state[11]=state[7]; state[7]=state[3];   state[3]=t;
}

static uint8_t xtime(uint8_t x)
{
    return (uint8_t)((x << 1) ^ (((x >> 7) & 1) * 0x1b));
}

static void mix_columns(uint8_t *state)
{
    uint8_t Tmp, Tm, t;
    for (int i = 0; i < 16; i += 4) {
        t   = state[i];
        Tmp = state[i] ^ state[i+1] ^ state[i+2] ^ state[i+3];
        Tm  = state[i]   ^ state[i+1]; Tm = xtime(Tm); state[i]   ^= Tm ^ Tmp;
        Tm  = state[i+1] ^ state[i+2]; Tm = xtime(Tm); state[i+1] ^= Tm ^ Tmp;
        Tm  = state[i+2] ^ state[i+3]; Tm = xtime(Tm); state[i+2] ^= Tm ^ Tmp;
        Tm  = state[i+3] ^ t;          Tm = xtime(Tm); state[i+3] ^= Tm ^ Tmp;
    }
}

void ccsds_aes128_encrypt_block(const uint8_t in[16],
                                const uint8_t round_keys[176], uint8_t out[16])
{
    uint8_t state[16];
    memcpy(state, in, 16);

    add_round_key(state, round_keys);
    for (int round = 1; round < 10; round++) {
        sub_bytes(state);
        shift_rows(state);
        mix_columns(state);
        add_round_key(state, &round_keys[round * 16]);
    }
    sub_bytes(state);
    shift_rows(state);
    add_round_key(state, &round_keys[10 * 16]);

    memcpy(out, state, 16);
}

void ccsds_aes128_ctr_xcrypt(uint8_t *buf, size_t len,
                             const uint8_t key[16], uint32_t timestamp)
{
    uint8_t round_keys[176];
    uint8_t iv[16] = {0};
    uint8_t keystream[16];
    size_t  blocks = (len + 15) / 16;

    ccsds_aes128_key_expansion(key, round_keys);

    /* IV = timestamp(4, BE) || zeros(8) || block_index(4, BE). */
    iv[0] = (uint8_t)(timestamp >> 24);
    iv[1] = (uint8_t)(timestamp >> 16);
    iv[2] = (uint8_t)(timestamp >> 8);
    iv[3] = (uint8_t)(timestamp);

    for (size_t b = 0; b < blocks; b++) {
        uint8_t block_iv[16];
        memcpy(block_iv, iv, 16);
        block_iv[12] = (uint8_t)(b >> 24);
        block_iv[13] = (uint8_t)(b >> 16);
        block_iv[14] = (uint8_t)(b >> 8);
        block_iv[15] = (uint8_t)(b);

        ccsds_aes128_encrypt_block(block_iv, round_keys, keystream);

        size_t start = b * 16;
        size_t end   = start + 16;
        if (end > len)
            end = len;
        for (size_t i = start; i < end; i++)
            buf[i] ^= keystream[i - start];
    }
}
